# Keil uVision project FOUR_PORTS_TESTER.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: FOUR_PORTS_TESTER +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT = 1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM
  c misc: --locale=ENGLISH
  c include: ..\source\CORE;..\source\SYSTEM\delay;..\source\SYSTEM\sys;..\source\SYSTEM\usart;..\source\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\source\SYS_LEVEL;..\source\HARDWARE\IIC;..\source\HARDWARE\LCD;..\source\HARDWARE\LED;..\source\HARDWARE\SRAM;..\source\HARDWARE\TIMER;..\source\HARDWARE\24CXX;..\source\HARDWARE\SPI;..\source\HARDWARE\SDIO;..\source\HARDWARE\TOUCH;..\source\HARDWARE\W25QXX;..\source\TEXT;..\source\USMART;..\source\FATFS\src;..\source\FATFS\src\option;..\source\MALLOC;..\source\FWLIB\CMSIS\Include;..\source\EMWIN\emWin\Config;..\source\EMWIN\emWin\emWinTask;..\source\EMWIN\Demo;..\source\UCOSIII\uC-CPU;..\source\UCOSIII\uC-LIB;..\source\UCOSIII\uCOS-III;..\source\UCOSIII\UCOS_BSP;..\source\UCOSIII\uCOS_CONFIG;..\source\UCOSIII\uCOS-III\Source;..\source\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\source\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\source\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\source\EMWIN_DEMO\NUM_DISPLAY;..\source\HARDWARE\RA8875\BSP;..\source\HARDWARE\RA8875\RA8875;..\source\EMWIN\emWin\Include;..\source\HARDWARE\KeyBoard;..\source\HARDWARE;..\source\HARDWARE\sd_card;..\source\HARDWARE\RTC;..\source\HARDWARE\SPI_FLASH;..\source\App;..\source\App\fonts;..\source\TESTER_UI;..\source\CS99XX;..\source\tools;..\source\USER_UI;..\source\USER_UI\UI;..\source\HARDWARE\CH376\inc;..\source\mem_manage;..\source\test_manage;..\source\usb_manage;..\source\key_manage;..\source\CS99XX_Type;..\source\parameter_manage;..\source\CORE\stm32f4xx;..\source\key_server
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x60000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x2800
  group SYS_LEVEL
    ../source/SYS_LEVEL/: stm32f4xx_it.c
  group HARDWARE
    ../source/HARDWARE/SRAM/: sram.c
    ../source/HARDWARE/24CXX/: 24cxx.c
    ../source/HARDWARE/IIC/: myiic.c
    ../source/HARDWARE/TOUCH/: ctiic.c
    ../source/HARDWARE/SPI/: spi.c
    ../source/HARDWARE/RTC/: rtc_config.c
    ../source/HARDWARE/LED/: bsp_led.c
    ../source/HARDWARE/SDIO/: bsp_sdio_sd.c
    ../source/HARDWARE/CODED_DISC/: coded_disc.c
    ../source/HARDWARE/SPI_FLASH/: spi_flash.c
    ../source/HARDWARE/: board.c
  group CORE
    ../source/CORE/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s
    ../source/CORE/stm32f4xx/: system_stm32f4xx.c
  group FWLIB
    ../source/FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../source/SYSTEM/delay/: delay.c
    ../source/SYSTEM/sys/: sys.c
    ../source/SYSTEM/usart/: usart.c
  group FATFS
    ../source/FATFS/src/: diskio.c ff.c
    ../source/FATFS/src/option/: syscall.c
  group DSP_LIB
    ../source/FWLIB/CMSIS/Include/: arm_math.h
    ../source/FWLIB/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group EMWIN_CONFIG
    ../source/EMWIN/emWin/Config/: GUIConf.c GUIConf.h LCDConf.c LCDConf.h
    ../source/EMWIN/emWin/DisplayDriver/: GUIDRV_Template.c
    ../source/EMWIN/emWin/GUI_X/: GUI_X_Ex.c GUI_X_Touch.c
  group EMWIN_LIB
    ../source/EMWIN/emWin/GUILib/: STemWin526_CM4_OS_Keil.lib
  group UCOSIII_BSP
    ../source/UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_CPU
    ../source/UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
    ../source/UCOSIII/uC-CPU/: cpu_core.c
  group UCOSIII_LIB
    ../source/UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../source/UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../source/UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../source/UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSIII_CONFIG
    ../source/UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group USMART
    ../source/USMART/: usmart.c usmart_config.c usmart_str.c
  group RA8875
    ../source/HARDWARE/RA8875/BSP/: bsp_tft_lcd.c
    ../source/HARDWARE/RA8875/RA8875/: LCD_RA8875.c bsp_ra8875_port.c
  group CH376
    ../source/HARDWARE/CH376/src/: CH376_USB_UI.C FILE_SYS.C HAL_BASE.C SPI_SW.C
  group Keyboard
    ../source/HARDWARE/KeyBoard/: Key_LED.c keyboard.c
  group APP
    ../source/App/: app.c
  group FONTS
    ../source/USER_UI/fonts/: fonts.h
    ../source/USER_UI/fonts/HZ/: hz_20.c hz_24.c hz_26.c hz_29.c
  group TYPE
    ../source/CS99XX_Type/: cs99xx_config.h cs99xx_type.c cs99xx_type.h cs99xx_type_config.h
  group CS99XX
    ../source/CS99XX/: cs99xx_struct.c
  group TOOLS
    ../source/tools/: cs_list.c mem_alloc.c tools.c
  group IMGAE
    ../source/USER_UI/image/: logo.c user_image.c
  group UI_COM
    ../source/USER_UI/UI_COM/: com_edit_api.c com_ui_info.c key_server.c
  group MAIN_WIN
    ../source/USER_UI/UI/main_win/: 7_main_win.c main_win.c
  group FILE_WIN
    ../source/USER_UI/UI/file_win/: file_edit_win.c file_win.c 7_file_win.c 7_file_edit_win.c
  group SYS_WIN
    ../source/USER_UI/UI/sys_win/: 7_sys_manage_win.c sys_manage_win.c
  group ENV_PAR_WIN
    ../source/USER_UI/UI/env_par_win/: 7_env_par_edit_win.c env_par_edit_win.c
  group KEY_MENU_WIN
    ../source/USER_UI/UI/key_menu_win/: 7_key_menu_win.c key_menu_win.c
  group TEST_WIN
    ../source/USER_UI/UI/test_win/: 7_test_ui_layout_1.c test_win.c
  group WARNING_WIN
    ../source/USER_UI/UI/warning_win/: 7_warning_win.c warning_win.c
  group SYS_TIME_WIN
    ../source/USER_UI/UI/sys_time_win/: 7_sys_time_edit_win.c sys_time_edit_win.c
  group STEP_PAR_WIN
    ../source/USER_UI/UI/step_par_win/: 7_step_edit_win.c step_edit_win.c 7_step_ui.c step_win.c
  group PASSWORD_WIN
    ../source/USER_UI/UI/password_win/: 7_password_win.c password_win.c 7_input_password_win.c input_password_win.c
  group RESTORE_SETTING_WIN
    ../source/USER_UI/UI/restore_setting_win/: 7_restore_setting_win.c restore_setting_win.c
  group RESULT_WIN
    ../source/USER_UI/UI/result_win/: 7_result_win.c result_win.c
  group DOCUMENT
    ../source/Document/: templet.c.txt
  group MEM_MANAGE
    ../source/mem_manage/: cs99xx_flash_manage.c cs99xx_mem_api.c
  group USB_MANAGE
    ../source/usb_manage/: cs99xx_usb_manager.c
  group TEST_MANAGE
    ../source/test_manage/: running_test.c
  group KEY_MANAGE
    ../source/key_manage/: key_fun_manage.c
  group PARAMETER_MANAGE
    ../source/parameter_manage/: parameter_manage.c
  group START_WIN
    ../source/USER_UI/UI/start_win/: 7_start_win.c start_win.c
  group SELF_CHECK_WIN
    ../source/USER_UI/UI/self_check_win/: 7_self_check_win.c self_check_win.c
